# Keil uVision project RTC_test.uvprojx, settings and files
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group Core
    ./Core/: sysinit.c sysinit.h i2c.c i2c.h lcd.c lcd.h delay.c delay.h rtc.c rtc.h gpio.c gpio.h scheduler.c scheduler.h matrix_keyboard.c matrix_keyboard.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
