# Keil uVision project rtc.uvprojx, settings and files
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group RTC
    ./: rtc.h rtc.c
  group UART
    ./: uart.h uart.c
  group I2C
    ./: i2c.h i2c.c
  group LCD
    ./: lcd.h lcd.c
  group Keyboard
    ./: keyboard.h keyboard.c
  group Scheduler
    ./: scheduler.h scheduler.c
  group GPIO
    ./: gpio.h gpio.c
  group Delay
    ./: delay.h delay.c
  group Sysinit
    ./: sysinit.c sysinit.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
